# Keil uVision project main_STM32L1xx.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: _KEIL, _HSE_BYPASS_ON,  xTERMINAL
  c include: .\src;C:\Bin\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;.\..\EmbSysLib\Src;.\..\EmbSysLib\Src\MCU\STM32L1xx
  asm define: Stack_Size=0xC00, Heap_Size=0x0C00
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Src
    ./Src/: main.cpp Task_Example.h RTOS_Task_Example.h
  group Lib
    ./../EmbSysLib/Src/: lib.cpp
    ./../EmbSysLib/Src/MCU/STM32L1xx/Sys/Keil/: startup_stm32l1xx_mdp.s RTOScontext.s
    ./../EmbSysLib/Src/Module/: RTOS.cpp
    ./../EmbSysLib/Src/Peripheral/: Disp_DIP204spi.cpp
